# Repository ararobo/HTMDv2.2s

## KiCad design HTMDv2.2s.kicad_pcb

Parts:
C1: 220u; CP_Radial_D10.0mm_P5.00mm
C2, C3, C13, C14, C15, C21, C22, C26, C28, C29: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C6: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C10, C11, C16, C17, C18, C19, C20, C23, C30: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C24: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25: 10p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2, D3, D4, D5, D6, D12, D13, D15, D16, D17, D18: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10, D11: D; SS2040FL
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
IC1: TJA1441AT_0Z; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
IC2: A3921KLPTR-T; A3944KLPTRT; Manufacturer_Part_Number A3921KLPTR-T
IC3: TMP275AQDGKRQ1; Mouser Part Number 595-TMP275AQDGKRQ1
J1, J2: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J3: Conn_01x06; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J4, J8: Conn_01x01; ねじ端子(縦)
J5, J7: Conn_01x01_Pin; ねじ端子(縦)
J6: Conn_01x02_Pin; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
J9: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J10, J11: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
JP2, JP3, JP4, JP5: SolderJumper_2_Open; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
L1: 0.47u; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1, R8, R12, R13, R14, R15, R38: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R31: 13k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R32: 2.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R9, R16, R33, R34, R35, R36, R37, R46, R47, R49, R50, R51, R52: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R17, R28, R29, R30: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 120; R_0603_1608Metric
R11, R26, R27: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R19, R24, R25: 10; R_0603_1608Metric
R20, R21, R22, R23: 10k; R_0603_1608Metric
R39: 88.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40: 19.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41: 100k; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
RV1, RV2: 10k; TSR-3296
SW1: SW_Coded; FR01FR16H-S
SW2, SW3: SW_Push; TVAF06
U1: TPS628511DRLR; DRL0008A-MFG
U2: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U3: ISO6741FDWR; ISO674x
U4: CZ3A07; CZ3AG6; Mouser Part Number 412-CZ3A07
U5: MCP3421A0T-ECH; SOT-23-6_Handsoldering
U13, U14, U15, U16: SQJ180EP-T1_GE3; PowerPAK_SO-8_Single

Connections:
+3.3V: C8.2, C9.1, C10.1, C11.1, C12.1, C15.1, C17.1, C18.1, C25.1, C28.1, C29.1, C30.1, C31.1, D11.2 (A), IC1.5 (VIO), IC3.8 (V+), J3.2, J9.4, J10.2, J11.2, L1.2, R2.1, R17.1, R28.1, R29.1, R30.1, R31.1, R39.1, R41.1, R46.1, SW1.1 (CM), U2.1 (VBAT), U2.20 (VREF+), U2.21 (VDDA), U2.23 (VDD), U2.35 (VDD), U2.48 (VDD), U3.1 (VCC1), U3.7 (EN1), U4.13 (VDD), U5.5 (Vdd)
+5VA: C7.1, C14.1, C20.1, IC2.20 (V5), R7.1, R12.1, R13.1, U3.10 (EN2), U3.16 (VCC2)
+24V: C1.1, C23.1, IC2.1 (VDRAIN), IC2.13 (VBB), J5.1, R14.1, U13.2, U16.2
CANH: IC1.7 (CANH), J1.4, J2.4, R10.1
CANL: IC1.6 (CANL), J1.2, J2.2, JP1.2 (B)
CAN_RX: IC1.4 (RXD), U2.33 (PA11)
CAN_TX: IC1.1 (TXD), U2.34 (PA12)
CP1: C13.2, IC2.15 (CP2)
ENC_A: JP4.2 (B), U2.30 (PA8)
ENC_B: JP5.2 (B), U2.31 (PA9)
GHA0: IC2.10 (GHA), R18.1
GHB0: IC2.5 (GHB), R24.1
GLA0: IC2.12 (GLA), R19.1
GLB0: IC2.3 (GLB), R25.1
GND: C2.2, C3.2, C4.2, C5.2, C8.1, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, C24.2, C28.2, C29.2, C30.2, C31.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D12.1 (K), D13.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), H4.1, IC1.2 (GND), IC1.8 (S), IC3.4 (GND), IC3.5 (A2), IC3.6 (A1), IC3.7 (A0), J1.1, J2.1, J3.4, J9.2, R1.2, R3.2, R4.1, R5.1, R6.1, R8.2, R9.1, R32.2, R38.2, R40.2, SW2.1, U1.8 (GND), U2.49 (VSS), U3.2 (GND1), U3.8 (GND1), U4.9 (VSS_1), U4.16 (VSS_2), U5.2 (Vss)
GNDPWR: C1.2, C7.2, C14.2, C20.2, C23.2, C26.2, C27.2, IC2.2 (LSS), IC2.17 (GND), IC2.29 (EP), J7.1, R11.2, R15.2, R21.2, R23.2, SW3.1, U3.9 (GND2), U3.15 (GND2), U14.3, U15.3
I2C_SCL: IC3.1 (SDA), R17.2, R28.2, U2.38 (PA15), U5.3 (SCL)
I2C_SDA: IC3.2 (SCL), R29.2, R30.2, U2.45 (PB7), U5.4 (SDA)
IN: J4.1, U4.5 (IN)
IP: C21.2, IC2.11 (SA), R20.2, U4.1 (IP), U13.3, U14.2
LED1: R37.1, U2.24 (PB11)
LED2: SW1.2 (D0), U2.19 (PB2)
LED3: SW1.3 (D1), U2.18 (PB1)
LED4: SW1.4 (D2), U2.17 (PB0)
LED5: SW1.5 (D3), U2.13 (PA5)
LED_CAN: R34.1, U2.32 (PA10)
LED_LIM1: R35.1, U2.44 (PB6)
LED_LIM2: R36.1, U2.41 (PB3)
LED_OCD: R33.1, U2.2 (PC13)
LIM1: J10.1, R1.1, U2.47 (PB9)
LIM2: J11.1, R8.1, U2.43 (PB5)
NRST: C16.1, SW2.2, U2.7 (PG10)
unnamed: D2.2 (A), R33.2
unnamed: D3.2 (A), R34.2
unnamed: D4.2 (A), R35.2
unnamed: D5.2 (A), R36.2
unnamed: D6.2 (A), R37.2
unnamed: C2.1, C3.1, D10.1 (K), U1.1 (VIN), U1.2 (EN), U1.3 (MODE_SYNC)
unnamed: D12.2 (A), R46.2
unnamed: D13.2 (A), R47.2
unnamed: D15.2 (A), R49.2
unnamed: D16.2 (A), R50.2
unnamed: D17.2 (A), R51.2
unnamed: D18.2 (A), R52.2
unnamed: C21.1, IC2.9 (CA)
unnamed: C22.2, IC2.6 (CB)
unnamed: C13.1, IC2.16 (CP1)
unnamed: IC2.25 (FF1), R13.2
unnamed: IC2.26 (FF2), R12.2
unnamed: IC2.27 (RDEAD), R15.1
unnamed: IC2.28 (VDSTH), R7.2, R11.1
unnamed: C26.1, C27.1, IC2.8 (VREG)
unnamed: J3.1, JP2.1 (A), JP4.1 (A)
unnamed: J3.3, JP3.1 (A), JP5.1 (A)
unnamed: JP1.1 (A), R10.2
unnamed: R2.2, RV1.1
unnamed: R3.1, RV1.3
unnamed: R18.2, R20.1, U13.1
unnamed: R19.2, R21.1, U14.1
unnamed: R22.1, R24.2, U16.1
unnamed: R23.1, R25.2, U15.1
unnamed: R31.2, RV2.1
unnamed: R32.1, RV2.3
unnamed: C25.2, R39.2, R40.1, U1.5 (FB)
unnamed: R41.2, U1.6 (PG)
unnamed: C24.1, U1.4 (SS_TR)
unnamed: L1.1, U1.7 (SW)
unnamed: R38.1, U2.46 (PB8)
unnamed: R26.1, U4.12 (VOUT)
unnamed: C6.1, R26.2, R27.2, U5.1 (Vin+)
unnamed: C6.2, R27.1, U5.6 (Vin-)
OCD1: U2.3 (PC14), U4.11 (OCD2)
OCD2: U2.4 (PC15), U4.10 (OCD1)
OPHASE1: R4.2, R16.1, R52.1, U2.11 (PA3), U3.3 (INA)
OPWMH1: R9.2, R16.2, R49.1, U2.8 (PA0), U3.6 (OUTD)
OPWML1: R6.2, R50.1, U2.9 (PA1), U3.5 (OUTC)
OSR1: R5.2, R51.1, U2.10 (PA2), U3.4 (INB)
PHASE1: IC2.19 (PHASE), U3.14 (OUTA)
PWMH1: IC2.23 (PWMH), U3.11 (IND)
PWML1: IC2.22 (PWML), U3.12 (INC)
RESET: IC2.24 (RESET), R14.2, SW3.2
SB1: C22.1, IC2.4 (SB), J8.1, R22.2, U15.2, U16.3
SPI_CS: J3.6, U2.25 (PB12)
SPI_MISO: JP3.2 (B), U2.27 (PB14)
SPI_MOSI: JP2.2 (B), U2.28 (PB15)
SPI_SCK: J3.5, U2.26 (PB13)
SR1: IC2.21 (SR), U3.13 (OUTB)
SWCLK: J9.3, U2.37 (PA14)
SWDIO: J9.1, U2.36 (PA13)
UART_RX: J6.2, U2.40 (PC11)
UART_TX: J6.1, U2.39 (PC10)
VCC: C19.1, D10.2 (A), D11.1 (K), IC1.3 (VCC), J1.3, J2.3, R47.1
VREF1: C4.1, RV1.2, U4.14 (REF1)
VREF2: C5.1, RV2.2, U4.15 (REF2)

Notes on the sheet:
MCU
電源ライン
ゲートドライバ,Hブリッジ
all 20kohm
通信用インターフェース
STLink
Jumper for use LAP
リセットSW
電流センサ
温度センサ
ホール
アイソレータ
CANトランシーバー

Board: 4 copper layers, 90.0 x 49.9 mm, 129 parts (18 on the bottom side), 94 nets.

File production/HTMDv2.2s_2023-10-21_23-55-13/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Radial_D10.0mm_P5.00mm,1,220u,
"C10, C11, C16, C17, C18, C19, C20, C23, C30, C7, C8",0603,11,0.1u,
"C12, C24",0603,2,4.7u,
"C13, C14, C15, C2, C21, C22, C26, C28, C29, C3",0805,10,10u,
C25,0603,1,10p,
C27,0805,1,0.1u,
C31,0603,1,1u,
"C4, C5, C6",0603,3,1n,
C9,0603,1,C,
"D1, D12, D13, D14, D15, D16, D17, D18, D2, D3, D4, D5, D6, D7, D8, D9",0603,16,LED,
"D10, D11",SS2040FL,2,D,
"H1, H2, H3",MountingHole_3.2mm_M3,3,MountingHole,
H4,MountingHole_3.2mm_M3_DIN965_Pad,1,MountingHole,
IC1,SOIC127P600X175-8N,1,TJA1441AT_0Z,
IC2,A3944KLPTRT,1,A3921KLPTR-T,
IC3,TMP275AQDGKRQ1,1,TMP275AQDGKRQ1,
"J1, J2",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,2,Conn_01x04,
"J10, J11",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,2,Conn_01x02,
J3,JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal,1,Conn_01x06,
"J4, J8",ねじ端子(縦),2,Conn_01x01,
"J5, J7",ねじ端子(縦),2,Conn_01x01_Pin,
J6,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Conn_01x02_Pin,
J9,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Open,
"JP2, JP3, JP4, JP5",0603,4,SolderJumper_2_Open,
L1,0603,1,0.47u,
"R1, R12, R13, R14, R15, R38, R8",0603,7,20k,
R10,0603,1,120,
"R11, R26, R27",0603,3,1k,
"R16, R33, R34, R35, R36, R37, R4, R42, R43, R44, R45, R46, R47, R48, R49, R5, R50, R51, R52, R6, R9",0603,21,R,
"R17, R20, R21, R22, R23, R28, R29, R30, R7",0603,9,10k,
"R18, R19, R24, R25",0603,4,10,
"R2, R31",0603,2,13k,
"R3, R32",0603,2,2.4k,
R39,0603,1,88.7k,
R40,0603,1,19.6k,
R41,0603,1,100k,
"RV1, RV2",TSR-3296,2,10k,
"SW2, SW3",TVAF06,2,SW_Push,
U1,DRL0008A-MFG,1,TPS628511DRLR,
"U13, U14, U15, U16",SQJ180EP-T1_GE3,4,SQJ180EP-T1_GE3,
U2,QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm,1,STM32G431CBUx,
U3,ISO674x,1,ISO6741FDWR,
U4,CZ3AG6,1,CZ3A07,
U5,SOT-23-6_Handsoldering,1,MCP3421A0T-ECH,

## Code that names these connections

File HTMDv2.2sg431/HTMDv2.2sg431.ioc (part):

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Mcu.Name=STM32G431C(6-8-B)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32G431CBUx
PA0.Signal=S_TIM2_CH1
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=PWM_L
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=LED_CAN
PA10.Signal=GPIO_Output
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=PHASE
PA2.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=SR
PA3.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=SPI1_CS
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED6
PA5.Signal=GPIO_Output
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LED4
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=LED3
PB1.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=LED1
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=SPI2_CS
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=LED2
PB2.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=DIP2
PB3.Signal=GPIO_Input
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=DPI3
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=DPI4
PB5.Signal=GPIO_Input
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=LED_lim1
PB6.Signal=GPIO_Output
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=LIM1
PB9.Signal=GPIO_Input
PC10.Mode=Asynchronous
PC10.Signal=USART3_TX
PC11.Mode=Asynchronous
PC11.Signal=USART3_RX
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=DIP1
PC13.Signal=GPIO_Input
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=OCD1
PC14-OSC32_IN.Signal=GPIO_Input
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=OCD2
PC15-OSC32_OUT.Signal=GPIO_Input
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=LED5
PC4.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=120000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File HTMDv2.2s.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=PWMH
PA0.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=PWML
PA1.Signal=S_TIM2_CH2
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=CAN_Activate
PA11.Signal=CAN_RX
PA12.Mode=CAN_Activate
PA12.Signal=CAN_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=SR
PA2.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=PHASE
PA3.Signal=GPIO_Output
PA8.Signal=S_TIM1_CH1
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI1_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI1_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI1_MOSI
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=8000000
board=custom

File HTMDv2.2sg431/Core/Inc/main.h:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.h
  * @brief          : Header for main.c file.
  *                   This file contains the common defines of the application.
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2023 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */

/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __MAIN_H
#define __MAIN_H

#ifdef __cplusplus
extern "C" {
#endif

/* Includes ------------------------------------------------------------------*/
#include "stm32g4xx_hal.h"

/* Private includes ----------------------------------------------------------*/
/* USER CODE BEGIN Includes */
#include "A3921Driver.hpp"
#include "CANManager.hpp"
/* USER CODE END Includes */

/* Exported types ------------------------------------------------------------*/
/* USER CODE BEGIN ET */

/* USER CODE END ET */

/* Exported constants --------------------------------------------------------*/
/* USER CODE BEGIN EC */

/* USER CODE END EC */

/* Exported macro ------------------------------------------------------------*/
/* USER CODE BEGIN EM */

/* USER CODE END EM */

/* Exported functions prototypes ---------------------------------------------*/
void Error_Handler(void);

/* USER CODE BEGIN EFP */

/* USER CODE END EFP */

/* Private defines -----------------------------------------------------------*/
#define LED_OCD_Pin GPIO_PIN_13
#define LED_OCD_GPIO_Port GPIOC
#define OCD1_Pin GPIO_PIN_14
#define OCD1_GPIO_Port GPIOC
#define OCD2_Pin GPIO_PIN_15
#define OCD2_GPIO_Port GPIOC
#define PWM_L_Pin GPIO_PIN_1
#define PWM_L_GPIO_Port GPIOA
#define PHASE_Pin GPIO_PIN_2
#define PHASE_GPIO_Port GPIOA
#define SR_Pin GPIO_PIN_3
#define SR_GPIO_Port GPIOA
#define SPI1_CS_Pin GPIO_PIN_4
#define SPI1_CS_GPIO_Port GPIOA
#define LED6_Pin GPIO_PIN_5
#define LED6_GPIO_Port GPIOA
#define LED5_Pin GPIO_PIN_4
#define LED5_GPIO_Port GPIOC
#define LED4_Pin GPIO_PIN_0
#define LED4_GPIO_Port GPIOB
#define LED3_Pin GPIO_PIN_1
#define LED3_GPIO_Port GPIOB
#define LED2_Pin GPIO_PIN_2
#define LED2_GPIO_Port GPIOB
#define LED1_Pin GPIO_PIN_11
#define LED1_GPIO_Port GPIOB
#define SPI2_CS_Pin GPIO_PIN_12
#define SPI2_CS_GPIO_Port GPIOB
#define LED_CAN_Pin GPIO_PIN_10
#define LED_CAN_GPIO_Port GPIOA
#define LED_lim2_Pin GPIO_PIN_3
#define LED_lim2_GPIO_Port GPIOB
#define LIM2_Pin GPIO_PIN_5
#define LIM2_GPIO_Port GPIOB
#define LED_lim1_Pin GPIO_PIN_6
#define LED_lim1_GPIO_Port GPIOB
#define LIM1_Pin GPIO_PIN_9
#define LIM1_GPIO_Port GPIOB

/* USER CODE BEGIN Private defines */
//TODO:インスタンスに値指定しろ
extern A3921Driver A3921DriverInstance;
/* USER CODE END Private defines */

#ifdef __cplusplus
}
#endif

#endif /* __MAIN_H */

## Commit log

2023-10-02 init commit
2023-10-05 update PCB
2023-10-07 update
    配線作業ちう
2023-10-07 update
    update pcb
2023-10-07 Update HTMDv2.2s.kicad_sch
    add LEDs
2023-10-07 update
    change footprints
2023-10-07 Update HTMDv2.2sg431.ioc
    pin changed
2023-10-07 update
    add power line
2023-10-07 update
    SYS配線の見直し
2023-10-07 pre cmpl
    レビューまち
2023-10-07 update
    change 3D models
2023-10-08 update
    温度センサ周りの配線
    プルダウン抵抗の位置変更
    ドライブラインのLED追加
2023-10-08 Update HTMDv2.2s.kicad_pcb
    配線の微調整
2023-10-08 Update HTMDv2.2s.kicad_pcb
    ねじ端子直下にビアを追加
2023-10-08 update
    ティアドロップの追加
    DRCの解消
2023-10-08 Update HTMDv2.2s.kicad_pcb
    パッド内の配線を削除
    重複した配線のマージ
    未配線ビア(GND除く)の削除
2023-10-08 update
    ノイズ対策を追加
2023-10-08 update
    導体スライパーの解決
2023-10-08 Update HTMDv2.2s.kicad_pcb
    シルクの再配置
    ティアドロップの修正
2023-10-08 update
    配線の修正
2023-10-08 Update HTMDv2.2s.kicad_sch
    回路定数が間違っていたのを修正
2023-10-08 update
    発注Done
2023-10-08 Create simpleBOM.xlsx
    BOMの追加
2023-10-10 generated HW
    stm32プロジェクト生成した
2023-10-10 change Makefile
    makefileの変更
    mainファイルをcからcppに変更
2023-10-11 update
    A3921Driverをcppからhppに変更
2023-10-11 update A3921Driver
2023-10-11 update
    整えた
2023-10-11 update
    CANManagerの作成
    PWMHのピンラベルを削除
2023-10-11 update
    CANマネージャの更新
2023-10-11 Update CANManager.cpp
    送受信関数の追加
2023-10-12 フォルダ整理
    App/Tasksを追加
    moduleディレクトリを追加
2023-10-12 CANManagerのクラス化
2023-10-12 PIDの空プログラムを追加
2023-10-12 CANManagerの分割
2023-10-12 update CANManager
2023-10-12 A3921Driverインスタンスの生成場所を決めた
2023-10-12 A3921のインスタンスを指定した
2023-10-17 MCP3421ライブラリを書き始めた
2023-10-21 回路の修正
2023-10-21 ガーバー
2023-12-18 prefin
